# Keil uVision project PCB_CHECK_FAX.uvprojx, settings and files
target PCB_CHECK_FAX (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: PCB_CHECK_FAX +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;   ../Drivers/STM32F1xx_HAL_Driver/Inc;   ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;   ../Drivers/CMSIS/Include;   ..\source;   ..\USMART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c gpio.c adc.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group source
    ../source/: BSP_74HC595.c BSP_74HC595.h BSP_74HC4051A.c BSP_74HC4051A.h BSP_74HC4052A.c BSP_74HC4052A.h BSP_ADC.c BSP_ADC.h BSP_BEEP.c BSP_BEEP.h BSP_Control.c BSP_Control.h BSP_Flash.c BSP_Flash.h BSP_FUN.c BSP_FUN.h BSP_KEY.c BSP_KEY.h BSP_LED.c BSP_LED.h BSP_MOTO.c BSP_MOTO.h BSP_Printer.c BSP_Printer.h BSP_PUBLIC.c BSP_PUBLIC.h DataType.c DataType.h Global.c Global.h INCLUDE_EXT.c INCLUDE_EXT.h IT.c IT.h MODE_XBR.c MODE_XBR.h MODE_XBR105.c MODE_XBR105.h MODE_XBR201.c MODE_XBR201.h MODE_XBR202.c MODE_XBR202.h MODE_XBR401.c MODE_XBR401.h systick.c systick.h Typedef.c Typedef.h
software components: CMSIS:CORE 5.1.2
