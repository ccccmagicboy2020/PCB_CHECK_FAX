# IAR project PCB_CHECK_FAX.ewp, settings and files
configuration PCB_CHECK_FAX (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PCB_CHECK_FAX.hex
  ILINK.IlinkOutputFile: PCB_CHECK_FAX.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c gpio.c adc.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group source
    ../source/: BSP_74HC4052A.c BSP_74HC4052A.h BSP_ADC.c BSP_ADC.h BSP_BEEP.c BSP_BEEP.h BSP_Control.c BSP_Control.h BSP_Flash.c BSP_Flash.h BSP_HC595.c BSP_HC595.h BSP_KEY.c BSP_KEY.h BSP_LED.c BSP_LED.h BSP_MOTO.c BSP_MOTO.h BSP_Printer.c BSP_Printer.h BSP_UART.c BSP_UART.h DataType.c DataType.h Filter.c Filter.h Global.c Global.h INCLUDE_EXT.c INCLUDE_EXT.h INTERRUPT_EXT.c INTERRUPT_EXT.h IT.c IT.h MODE_RODAR.c MODE_RODAR.h MODE_XBR105.c MODE_XBR105.h MODE_XBR201.c MODE_XBR201.h PRINTF.c PRINTF.h RC_DataAnalysis.c RC_DataAnalysis.h systick.c systick.h Typedef.c Typedef.h
  group USMART
    ../USMART/: usmart.c usmart.h usmart_config.c usmart_str.c usmart_str.h
